## Kconfig
```kconfig
menu "MyNVS 组件配置"
    config MAX_NAMESPACE
        int "操作名字空间数量"
        default 4
        help
            "配置最多能够同时打开的名字空间数量"
endmenu
```
